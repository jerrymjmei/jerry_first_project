options:
  parameters:
    generate_options: qt_gui
    id: ham_7th_NFM_public_Radio
    output_language: python
  states: {}

blocks:
- name: RF_gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,3,1,1]'
    label: RF_GAIN
    maximum: '48'
    minimum: '0'
    minsize: '200'
    relBackgroundColor: silver
    showvalue: '1'
    type: real
    value: '0'
  states: {}
- name: channel_Freq
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,2,1,1]'
    label: FREQUENCY
    maximum: '146000'
    minimum: '144000'
    minsize: '200'
    relBackgroundColor: lime
    showvalue: '5'
    type: real
    value: '145775'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: noise_squelch
  id: variable_qtgui_range
  parameters:
    label: Noise_mute_level
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2400e3
  states: {}
- name: vol_control_0
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,1,1,1]'
    label: Vol
    maximum: '100'
    minimum: '0'
    minsize: '200'
    relBackgroundColor: blue
    showvalue: '1'
    type: real
    value: '0'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.2e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: noise_squelch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_control_0
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '25'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/100
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 200e3
    freq0: channel_Freq*1e3+1.2e6
    gain0: RF_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: channel_Freq*1e3
    fftsize: '1024'
    name: '"Frequency spectrum"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: '96000'
    type: float
    update_time: '0.1'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: '96000'
    type: float
    update_time: '0.1'
    ylabel: BPSK
    ymax: '10'
    ymin: '-10'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '1200'
    differential: 'False'
    f_offset: '0'
    manchester: 'False'
    samp_rate: samp_rate/25
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', high_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [high_pass_filter_0, '0', satellites_bpsk_demodulator_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [satellites_bpsk_demodulator_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
