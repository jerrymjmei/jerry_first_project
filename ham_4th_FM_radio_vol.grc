options:
  parameters:
    generate_options: qt_gui
    id: ham_2_Channel_FM_Radio_Pentoo
    output_language: python
  states: {}

blocks:
- name: Audio_volumn
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 2,1
    label: Audio_volumn
    maximum: '100'
    minimum: '0'
    showvalue: 'False'
    type: int
    value: '0'
  states: {}
- name: RF_gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,5,2,2]'
    label: RF_GAIN
    maximum: '48'
    minimum: '0'
    minsize: '200'
    relBackgroundColor: blue
    showvalue: '1'
    type: real
    value: '5'
  states: {}
- name: channel_Freq
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,3,2,2]'
    label: FREQUENCY
    maximum: '1080'
    minimum: '880'
    minsize: '200'
    relBackgroundColor: lime
    showvalue: '1'
    type: real
    value: '1037'
  states: {}
- name: channel_Freq_1
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,7,2,2]'
    label: FREQUENCY_delta
    maximum: '0'
    minimum: '-24'
    minsize: '200'
    relBackgroundColor: teal
    showvalue: '1'
    type: real
    value: '0'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2400e3
  states: {}
- name: vol_BIAS_0
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: '[1,1,1,1]'
    label: Vol
    maximum: '100'
    minimum: '0'
    relBackgroundColor: blue
    showvalue: '1'
    type: real
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1.2e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: channel_Freq_1*1e5+1.2e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_BIAS_0/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (100-vol_BIAS_0)/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_volumn/100
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_BLACKMAN
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 200e3
    freq0: channel_Freq*1e5+1.2e6
    gain0: RF_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*2
    fc: channel_Freq*1e5
    fftsize: '1024'
    gui_hint: '[3,1,4,4]'
    name: '"Frequency spectrum"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 100e3
    fc: 50e3
    fftsize: '1024'
    gui_hint: '[3,5,4,4]'
    name: '"Delta_frequency"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '1'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '1'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_rcv_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
